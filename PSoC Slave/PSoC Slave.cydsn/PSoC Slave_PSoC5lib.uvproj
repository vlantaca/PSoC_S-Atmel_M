# Keil uVision project PSoC Slave_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: PSoC Slave_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h SW2_aliases.h SW2.c SW2.h Debounce_Clock.c Debounce_Clock.h Pin_12_4_aliases.h Pin_12_4.c Pin_12_4.h SW3_aliases.h SW3.c SW3.h SCL_EZI2C_aliases.h SCL_EZI2C.c SCL_EZI2C.h Pin_12_7_aliases.h Pin_12_7.c Pin_12_7.h SDA_EZI2C_aliases.h SDA_EZI2C.c SDA_EZI2C.h EZI2C.c EZI2C.h EZI2C_PM.c EZI2C_INT.c LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LED3_aliases.h LED3.c LED3.h LED4_aliases.h LED4.c LED4.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: PSoC Slave_PSoC5lib (library)
